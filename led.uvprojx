# Keil uVision project led.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led +hex
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: .\Stm32F303_FW\CMSIS\Include;.\Stm32F303_FW\CMSIS\Device\ST\STM32F30x\Include;.\Stm32F303_FW\STM32F30x_StdPeriph_Driver\inc;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group STM32F303_FW
    ./Stm32F303_FW/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group User
    ./User/: main.c stm32f30x_it.c system_stm32f30x.c
  group Startup
    ./Stm32F303_FW/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s startup_stm32f302x8.s startup_stm32f303xc.s startup_stm32f303xe.s startup_stm32f334x8.s
